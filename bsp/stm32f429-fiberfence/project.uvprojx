# Keil uVision project project.uvprojx, settings and files
target rt_thread_stm32f429 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: applications;.;drivers;Libraries\STM32F4xx_HAL_Driver\Inc;Libraries\CMSIS\Device\ST\STM32F4xx\Include;Libraries\CMSIS\Include;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\dfs\include;..\..\components\dfs\filesystems\elmfat;..\..\components\dfs\filesystems\devfs;..\..\components\net\lwip-1.4.1\src;..\..\components\net\lwip-1.4.1\src\include;..\..\components\net\lwip-1.4.1\src\include\ipv4;..\..\components\net\lwip-1.4.1\src\arch\include;..\..\components\net\lwip-1.4.1\src\include\netif;.\DSP_lib\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f429_flash.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c delay.c adc_timer.c displayInfo.c
    ./applications/: udp_demo.c udp_server.c key_app.c cpuusage.c finsh_debug.c file_test.c dsp.c
  group Drivers
    drivers/: board.c stm32f4xx_it.c usart.c drv_rtc.c drv_gpio.c drv_spi.c drv_spi_flash.c drv_spi_dac.c drv_spi_adc.c drv_iic.c drv_eeprom.c
    ./drivers/: AD7924.c myspi.c key.c drv_eth.c drv_sdio_sd.c lcd.c
  group STM32_HAL
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    ./Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fmc.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_w25qxx.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group LWIP_NETIF
    ../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_ARCH
    ../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group LWIP_API
    ../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group DSP_lib
    ./DSP_lib/: arm_cortexM4lf_math.lib
